# Keil uVision project Blinky.uvprojx, settings and files
target S32K144 RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144UAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  asm define: RAM_TARGET
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UAxxxLLx\S32K144_64_ram.sct
  group Source Group 1
    ./: main.c S32K144_API.c S32K144_API.h MainTask.c Task.h Task1.c Task2.c task3.c task4.c SystemConfig.h function.c function.h Bms-Input-Output-Port.h
  group Documentation
    ./: 记录文件.txt Abstract.txt
  group CCP
    ./: CCP.C ccp_can_interface.C CCP.H ccp_can_interface.H CCPPAR.H
target S32K144 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144UAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: as above
  output: SVC(V100)控制程序 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\RTX5_Blinky
  asm include: ..\RTX5_Blinky
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UAxxxLLx\S32K144_64_flash.sct
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.3.0, Device:SDK Driver:ADC 1.0.0, Device:SDK Driver:Clock 1.0.0, Device:SDK Driver:Interrupt 1.0.0, Device:SDK Driver:PINS 1.0.0, Device:Startup 2.0.0
